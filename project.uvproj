# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=4 oTime=1 wLevel=2
  c misc: --forceinline
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup code
    ./: startup_LPC17xx.s
  group Source code
    ./: main.c GLCD_Scroll.c GLCD_SPI_LPC1700.c half_fit.c half_fit_test.c Retarget.c uart.c
  group System code
    ./: system_LPC17xx.c
